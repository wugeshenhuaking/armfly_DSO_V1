# Keil uVision project project.uvproj, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC5)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,ARM_MATH_CM4,__FPU_PRESENT
  c misc: --diag_suppress=870
  c include: ..\..\User;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\User\fonts;..\..\emWin\GUI_X;..\..\emWin\Config;..\..\emWin\Include;..\..\emWin\emWinTask;..\..\uCOS-III\uC-CPU;..\..\uCOS-III\uC-LIB;..\..\uCOS-III\uCOS-III\Ports;..\..\uCOS-III\uCOS-III\Source;..\..\uCOS-III\uC-CPU\ARM-Cortex-M4\RealView;..\..\uCOS-III\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\uCOS-III\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\User\fatfs\src;..\..\User\bsp_stm32f4xx;..\..\User\bsp_stm32f4xx\inc;..\..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c os_cfg_app.h app_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h
    ../../User/bsp_stm32f4xx/: stm32f4xx_it.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group BSP
    ../../User/bsp_stm32f4xx/: bsp.c bsp.h bsp_os.c
    ../../User/bsp_stm32f4xx/src/: bsp_cpu_flash.c bsp_eeprom_24xx.c bsp_fsmc_sram.c bsp_i2c_gpio.c bsp_key.c bsp_led.c bsp_nor_flash.c bsp_sdio_sd.c bsp_spi_flash.c bsp_dac.c bsp_adc.c bsp_spi_bus.c bsp_tim_pwm.c bsp_uart_fifo.c
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_iwdg.c stm32f4xx_tim.c stm32f4xx_wwdg.c stm32f4xx_crc.c stm32f4xx_spi.c stm32f4xx_fsmc.c stm32f4xx_sdio.c stm32f4xx_dma.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_dcmi.c stm32f4xx_adc.c stm32f4xx_flash.c stm32f4xx_dac.c
  group CMSIS
    ../../User/bsp_stm32f4xx/: system_stm32f4xx.c
  group LCD_Driver
    ../../emWin/DisplayDriver/: GUIDRV_Template.c
    ../../User/bsp_stm32f4xx/src/: bsp_touch.c LCD_RA8875.c LCD_SPFD5420.c bsp_tft_lcd.c bsp_ra8875_flash.c bsp_ra8875_port.c param.c LCD_ILI9488.c bsp_tsc2046.c bsp_gt811.c bsp_ts_ft5x06.c
  group fonts
    ../../User/fonts/: asc12.c asc16.c fonts.h hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c
  group GUI_X
    ../../emWin/GUI_X/: GUI_X_Ex.c
  group GUI/Config
    ../../emWin/Config/: GUIConf.c GUIConf.h LCDConf.c LCDConf.h
  group GUI/DSO
    ../../emWin/emWinTask/: MainTask.c MainTask.h App_SysFunction.c DSO_Init.c DSO_MeasureDlg.c DSO_InspectorDlg.c DSO_AcquireDlg.c DSO_TriggerDlg.c DSO_MathDlg.c DSO_SettingDlg.c DSO_DacDlg.c DSO_ReturnDlg.c DSO_DrawBakFrame.c DSO_DrawCursorH.c DSO_DrawCursorV.c DSO_AmplitudeWindow.c DSO_ScaleWindow.c DSO_StatusWindow.c DSO_FirFilter_Step1KHz.c DSO_FirFilter_Step10KHz.c DSO_FirFilter_Step100KHz.c
  group GUI/Lib
    ../../emWin/GUILib/: STemWin528_CM4_OS_Keil_ot.lib
  group uC/CPU
    ../../uCOS-III/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../uCOS-III/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../uCOS-III/uC-LIB/: lib_str.h lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c
    ../../uCOS-III/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../../uCOS-III/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/OS-III Port
    ../../uCOS-III/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group FatFS
    ../../User/fatfs/src/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
    ../../User/fatfs/src/option/: syscall.c
  group DSP_Lib
    ../../Libraries/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.开发环境说明.txt 04.STM32F407IGT6引脚定义(原始定义).txt 05.GPIO分配表(按GPIO次序排列).txt 06.GPIO分配表(按功能排列).txt
